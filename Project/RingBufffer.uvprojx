# Keil uVision project RingBufffer.uvprojx, settings and files
target RingBufffer (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F031C6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x8000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: RingBufffer +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HSI,USE_STDPERIPH_DRIVER,STM32F031
  c include: ..\CMSIS;..\StdPeriph_Driver\inc;..\System;..\Project;..\Driver;..\Middle
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../CMSIS/: startup_stm32f031.s system_stm32f0xx.c
  group System
    ../System/: sys.c
  group StdPeriph_Driver
    ../StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group Driver
    ../Driver/: timer.c usart.c
  group Middle
    ../Middle/: queue.c
  group User
    ./: main.c stm32f0xx_it.c
